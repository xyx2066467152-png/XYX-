# Keil uVision project AccessSkeleton.uvprojx, settings and files
target STM32F103RCT6_HAL_FreeRTOS (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: AccessSkeleton +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: .\Core\Inc;D:\STM32_project\STM32F1xx\STM32F1xx_HAL\CMSIS\Core\Include;D:\STM32_project\STM32F1xx\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;D:\STM32_project\STM32F1xx\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\BSP\Inc;.\Drivers\Inc;.\Services\Inc;.\App\Inc;.\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Core
    Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c freertos_hooks.c
    Core/Inc/: main.h stm32f1xx_it.h stm32f1xx_hal_conf.h FreeRTOSConfig.h
  group Application
    App/Src/: app_tasks.c key_task.c led_task.c app_task_entries.h access_task.c face_task.c rfid_task.c
    App/Inc/: app_tasks.h app_events.h
  group BSP
    BSP/Inc/: bsp.h bsp_key.h bsp_led.h bsp_uart.h bsp_i2c.h bsp_servo.h bsp_spi.h
    BSP/Src/: bsp.c bsp_key.c bsp_led.c bsp_uart.c bsp_i2c.c bsp_servo.c bsp_spi.c
  group Drivers
    Drivers/: README.md
    Drivers/Src/: oled_ssd1315.c k230_protocol.c rc522.c servo.c
    Drivers/Inc/: oled_ssd1315.h k230_protocol.h rc522.h servo.h
  group Services
    Services/Src/: log.c face_auth.c
    Services/Inc/: log.h face_auth.h
  group Config
    Config/: app_config.h
  group CMSIS
    D:/STM32_project/STM32F1xx/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    D:/STM32_project/STM32F1xx/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group HAL_Driver
    D:/STM32_project/STM32F1xx/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group FreeRTOS Kernel
    FreeRTOS/Source/: tasks.c queue.c list.c timers.c event_groups.c
  group FreeRTOS Portable
    FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS Memory
    FreeRTOS/Source/portable/MemMang/: heap_4.c
